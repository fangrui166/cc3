<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\bootloader\EWARM\cc_c_bl.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\application\EWARM\cc_c_app.ewp</path>
  </project>
  <batchBuild />
</workspace>
