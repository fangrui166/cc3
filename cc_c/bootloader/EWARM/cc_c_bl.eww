<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\cc_c_bl.ewp</path>
  </project>
  <batchBuild />
</workspace>
