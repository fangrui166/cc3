# IAR project cc_c_app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE; CC_TRACE_DEBUG
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/SIM900A/inc; ../Middlewares/MQTT; ../Middlewares/inc; ../../../global; ../Drivers/inc; ../../flash_define
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: cc_c_app.bin
  ILINK.IlinkOutputFile: cc_c.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
  group Application/User
    ../Src/: cJSON.c CLCPL.c command.c common.c communication_service.c freertos.c freertos_trace.c iap.c main.c mqtt.c myprintf.c NPL.C rtc_drv.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_it.c transport.c version.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SD
    ../Drivers/sd/: spi_sd_drv.c
  group Drivers/SIM900A
    ../Drivers/SIM900A/Src/: sim900a.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_wwdg.c
  group Drivers/uart
    ../Drivers/uart/: uart1_drv.c uart2_drv.c uart3_drv.c uart4_drv.c uart5_drv.c uart_drv.c
  group Drivers/watchdog
    ../Drivers/watchdog/: watchdog.c
  group Middlewares/Charger_manager
    ../Middlewares/charger_manager/: charger_manager.c
  group Middlewares/FATFS
    ../Middlewares/FATFS/: diskio.c tff.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Middlewares/http
    ../Middlewares/http/: http_post.c
  group Middlewares/hw_self_inspection
    ../Middlewares/hw_self_inspection/: hw_self_inspection.c
  group Middlewares/MQTT
    ../Middlewares/MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
